# Keil uVision project CH32F10x.uvprojx, settings and files
target CH32F10x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH32F103R8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F10x +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\Debug;.\DebugConfig;.\list;.\obj;.\Startup;.\StdPeriphDriver\src;.\StdPeriphDriver\inc;..\GPIO_Toggle;.\Hardware;.\System
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: ch32f10x_it.c Main.c system_ch32f10x.c
  group startup
    ./Startup/: startup_ch32f10x.s
  group core
    ./CMSIS/: core_cm3.c
  group debug
    ./Debug/: debug.c
  group peripheral
    ./StdPeriphDriver/src/: ch32f10x_adc.c ch32f10x_bkp.c ch32f10x_can.c ch32f10x_crc.c ch32f10x_dac.c ch32f10x_dbgmcu.c ch32f10x_dma.c ch32f10x_exti.c ch32f10x_flash.c ch32f10x_gpio.c ch32f10x_i2c.c ch32f10x_iwdg.c ch32f10x_misc.c ch32f10x_pwr.c ch32f10x_rcc.c ch32f10x_rtc.c ch32f10x_spi.c ch32f10x_tim.c ch32f10x_usart.c ch32f10x_usb.c ch32f10x_wwdg.c
  group HARDWARE
    ./Hardware/: as608.c BUZZER.c key.c oled_iic.c PWM.c RC522.c Servo.c timer.c usart3.c as608.h BUZZER.h key.h oled_iic.h oledfont.h PWM.h RC522.h Servo.h timer.h usart3.h
  group SYSETM
    ./System/: Flash.c sys.c Flash.h sys.h
